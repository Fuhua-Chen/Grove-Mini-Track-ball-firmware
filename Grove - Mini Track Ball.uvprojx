# Keil uVision project Grove - Mini Track Ball.uvprojx, settings and files
target Grove - Mini Track Ball (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GroveMiniTrackBall +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\Output\GroveMiniTrackball.bin .\Output\GroveMiniTrackBall.axf
  c flags: Optim=1
  c include: .\RTE;.\User;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8005000 size 0xb000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c init.c led.c communication.c Movement.c
target Grove - Mini Track Ball Bootloader (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: Grove - Mini Track Ball +hex
  c flags: Optim=1
  c include: .\RTE;.\User;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
